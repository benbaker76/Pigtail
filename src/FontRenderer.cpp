#include "FontRenderer.h"
#include "Indexed4bppImage.h"

#include <cstddef>
#include <cstdint>
#include <vector>
#include <string_view>

//   - Font is 4x5.
//   - Each row is stored as a 4-bit nibble.
//   - Two rows are packed per byte (high nibble first).
static const std::uint8_t kFontData[] = {
    0x00, 0x00, 0x04, 0x44, 0x04, 0xaa, 0x00, 0x0a, 0xea, 0xea, 0x6c, 0x6e, 0x4a, 0x24, 0x8a, 0x6c,
    0x6a, 0x64, 0x40, 0x00, 0x48, 0x88, 0x44, 0x22, 0x24, 0xa4, 0xa0, 0x00, 0x4e, 0x40, 0x00, 0x00,
    0x40, 0x0e, 0x00, 0x00, 0x00, 0x82, 0x24, 0x88, 0xea, 0xaa, 0xec, 0x44, 0x4e, 0xe2, 0xe8, 0xee,
    0x2e, 0x2e, 0xaa, 0xe2, 0x2e, 0x8e, 0x2e, 0xe8, 0xea, 0xee, 0x22, 0x22, 0xea, 0xea, 0xee, 0xae,
    0x2e, 0x00, 0x40, 0x40, 0x04, 0x04, 0x24, 0x84, 0x20, 0xe0, 0xe0, 0x84, 0x24, 0x8e, 0x26, 0x04,
    0x4a, 0xa8, 0x64, 0xae, 0xaa, 0xca, 0xca, 0xc6, 0x88, 0x86, 0xca, 0xaa, 0xce, 0x8c, 0x8e, 0xe8,
    0xc8, 0x86, 0x8a, 0xa6, 0xaa, 0xea, 0xae, 0x44, 0x4e, 0x22, 0x2a, 0x4a, 0xac, 0xaa, 0x88, 0x88,
    0xea, 0xee, 0xaa, 0xea, 0xaa, 0xa4, 0xaa, 0xa4, 0xea, 0xe8, 0x86, 0xaa, 0xc6, 0xca, 0xca, 0xa6,
    0x8e, 0x2c, 0xe4, 0x44, 0x4a, 0xaa, 0xae, 0xaa, 0xa4, 0x4a, 0xae, 0xea, 0xaa, 0x4a, 0xaa, 0xa4,
    0x44, 0xe2, 0x48, 0xe6, 0x44, 0x46, 0x88, 0x42, 0x2c, 0x44, 0x4c, 0x4a, 0x00, 0x00, 0x00, 0x0e,
    0x84, 0x00, 0x00, 0x6a, 0xa6, 0x8c, 0xaa, 0xc0, 0x68, 0x86, 0x26, 0xaa, 0x60, 0x4a, 0xc6, 0x24,
    0xe4, 0x40, 0x4a, 0x62, 0x88, 0xca, 0xa0, 0x40, 0x44, 0x04, 0x04, 0x48, 0xac, 0xaa, 0x44, 0x44,
    0x20, 0xae, 0xaa, 0x0c, 0xaa, 0xa0, 0x4a, 0xa4, 0x0c, 0xaa, 0xc0, 0x6a, 0xa6, 0x04, 0xa8, 0x80,
    0x68, 0x2c, 0x4e, 0x44, 0x20, 0xaa, 0xa6, 0x0a, 0xa4, 0x40, 0xaa, 0xea, 0x0a, 0x44, 0xa0, 0xaa,
    0x62, 0x0e, 0x28, 0xe6, 0x48, 0x46, 0x44, 0x44, 0x4c, 0x42, 0x4c, 0x0c, 0x60, 0x00, 0x00, 0x00,
};

static constexpr std::size_t kFontDataSize = sizeof(kFontData) / sizeof(kFontData[0]);

void FontRenderer::DrawGlyph(Indexed4bppImage& imageData,
                            std::uint8_t colorIndex,
                            int x,
                            int y,
                            int glyphIndex) const
{
    const int imageWidth  = imageData.Width();
    const int imageHeight = imageData.Height();
    if (imageWidth <= 0 || imageHeight <= 0)
        return;

    const int w = GlyphWidth;
    const int h = GlyphHeight;

    const int totalNibbles = static_cast<int>(kFontDataSize * 2);
    const int glyphCount   = totalNibbles / h;
    if (glyphIndex < 0 || glyphIndex >= glyphCount)
        return;

    const int glyphNibbleBase = glyphIndex * h;
    colorIndex &= 0x0F; // 4bpp palette index

    for (int row = 0; row < h; ++row)
    {
        const int destY = y + row;
        if ((unsigned)destY >= (unsigned)imageHeight)
            continue;

        const int nibbleIndex = glyphNibbleBase + row;
        const int byteIndex   = nibbleIndex >> 1;
        const bool highNibble = (nibbleIndex & 1) == 0;

        const std::uint8_t packed = kFontData[(std::size_t)byteIndex];
        const int rowBits = highNibble ? (packed >> 4) : (packed & 0x0F);

        for (int col = 0; col < w; ++col)
        {
            const int destX = x + col;
            if ((unsigned)destX >= (unsigned)imageWidth)
                continue;

            if ((rowBits & (1 << (3 - col))) != 0)
            {
                imageData.At(destX, destY) = colorIndex; // Indexed4bppImage handles 4bpp packing
            }
        }
    }
}

void FontRenderer::DrawText(Indexed4bppImage& imageData,
                           std::uint8_t colorIndex,
                           int x,
                           int y,
                           std::string_view text) const
{
    for (char ch : text)
    {
        const int glyphIndex = (int)(unsigned char)ch - 32;
        DrawGlyph(imageData, colorIndex, x, y, glyphIndex);
        x += GlyphWidth;
    }
}
